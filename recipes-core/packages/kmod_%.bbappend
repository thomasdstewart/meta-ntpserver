LDFLAGS:append:class-target = " -latomic"
