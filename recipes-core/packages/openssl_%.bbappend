EXTRA_OECONF:append:class-target = " -latomic"
