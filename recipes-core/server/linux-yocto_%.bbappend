COMPATIBLE_MACHINE += " galleon"
